Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Chairs-Stools-Benches_SAVO_Savo-Soul.ifc
Time: 2021-06-04T16:18:03
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Savo Soul
ePset_BIMobjectScript - Type: Soul 40; Edition: Polished Aluminium; Armrest: Off; Back Color: Beige - Fabric; Seat Color: Beige - Fabric; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Savo Soul; SKU (BO_prodsku): SavoSoul; ManufacturName (BO_Manufac): SAVO; BrandUrl (BO_brandurl): http://www.savo.com; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): Chairs; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 12/19/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/savo/product/SavoSoul; ProductDataUrl (BO_prodaturl): bimobject.com/savo/product/SavoSoul; ProductUrl (BO_producturl): http://www.savo.com/Products/Savo-Soul; InstallationInstructions (BO_montins): http://www.savo.com/Products/Savo-Soul; ProductCertification (BO_prodcert): http://www.savo.com/Products/Savo-Soul; MaterialMain (BO_mainmat): Aluminium; MaterialSecondary (BO_secmat): Fabric; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Chairs, Stools & Benches; BimObjectCategoryCode (BO_bocat_code): furniture-chairs-stools-benches; IfcClassification (BO_ifcclas): Furniture; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; Uniclass20Code (BO_uniclass_2_0_code): PR-31-12; Uniclass20Description (BO_uniclass_2_0_desc): Chairs, Seats And Bench Seating; Uniclass2015Code (BO_uniclass2015_code): Pr_40_50_12; Uniclass2015Description (BO_uniclass2015_desc): Chairs, seats and benches; NBSReference (BO_nbs_ref): 31-12; NBSReferenceDescription (BO_nbs_desc): Chairs, Seats And Bench Seating; OmniClassCode (BO_omniclass_code): 23-21 00 00; OmniClassDescription (BO_omniclass_name): Furnishings, Fixtures and Equipment Products; MasterFormat2014Code (BO_masterformat2014_code): 12 00 00; MasterFormat2014Description (BO_masterformat2014_name): Furnishings; RegionEurope (BO_europe): AX, DK, FI, GB, IS, NO, SE
